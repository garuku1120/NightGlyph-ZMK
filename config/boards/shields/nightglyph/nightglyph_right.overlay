#include "nightglyph.dtsi"

/*
 * 右側（ペリフェラル）：合体マトリクスの列6-11を担当。
 * 物理列(0-5)に +6 のオフセットを足して論理列6-11にマッピングする。
 */
&default_transform {
    col-offset = <6>;
};
